# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=1
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group Libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x_it.c
    ../User/bsp_DisplayTIM/: bsp_DisplayTIM.c
    ../User/bsp_drawgraph/: bsp_drawgraph.c
    ../User/font/: fonts.c
    ../User/bsp_pwm/: bsp_pwm.c
    ../User/bsp_basetim/: bsp_basetim.c
    ../User/bsp_PulseCap_EXTI/: bsp_PulseCap_EXTI.c
    ../User/bsp_led/: bsp_led.c
    ../User/bsp_printf/: bsp_printf.c
    ../User/bsp_key/: bsp_key.c
    ../User/delay/: delay.c
    ../User/bsp_coder/: bsp_coder.c
    ../User/bsp_param/: bsp_param.c
    ../User/bsp_usart/: bsp_usart.c
    ../User/bsp_I2c/: i2c.c
    ../User/bsp_eeprom/: eeprom.c
  group Doc
    ../Doc/: readme.txt
